# Keil uVision project lidar.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lidar
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\drv\inc;.\api\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./: main.c
  group GPIO
    ./drv/inc/: gpio.h
    ./drv/src/: gpio.c
  group USART
    ./drv/inc/: uart.h
    ./drv/src/: uart.c
  group I2C
    ./drv/inc/: i2c.h
    ./drv/src/: i2c.c
  group api_inc
    ./api/inc/: vl53l0x_api.h vl53l0x_api_calibration.h vl53l0x_api_core.h vl53l0x_api_ranging.h vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_i2c_platform.h vl53l0x_interrupt_threshold_settings.h vl53l0x_platform.h vl53l0x_platform_log.h vl53l0x_tuning.h vl53l0x_types.h
  group api_src
    ./api/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_i2c_platform.c vl53l0x_i2c_win_serial_comms.c vl53l0x_platform.c vl53l0x_platform_log.c
  group Timing
    ./drv/inc/: timing.h
    ./drv/src/: timing.c
  group VL53L0X
    ./drv/inc/: VL53L0X.h
    ./drv/src/: VL53L0X.c
  group Stepper
    ./drv/inc/: stepper.h
    ./drv/src/: stepper.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
